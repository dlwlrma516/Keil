# Keil uVision project potentiometer_measure.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: potentiometer_measure +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: main.c XPT2046.c
  group Include Files
    ./: XPT2046.h
